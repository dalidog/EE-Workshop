# Repository dalidog/EE-Workshop

## EAGLE design Lesson 5/E-Piano-SM.brd

Board: 2 copper layers, 100.0 x 38.1 mm, 24 parts (0 on the bottom side), 16 nets.

Parts:
BATT: AB9V
C1, C2: 0.1uF; C0805
LS1: F/HMB
Q1: BCW66; SOT23-BEC
R1, R6, R10: 1K; R0805
R2: 1.5K; R0805
R3: 1.3K; R0805
R4: 620; R0805
R5: 1.1K; R0805
R7: 910; R0805
R8: 390; R0805
R9: 6.2K; R0805
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8: MOMENTARY-SWITCH-SPST-SMD-6.2MM-TALL; TACTILE_SWITCH_SMD_6.2MM_TALL
U1: NE555D; SO08

Connections:
0: BATT.-, C1.2, C2.2, Q1.E, U1.1
unnamed: R8.2, R9.2, SW8.B2
unnamed: R9.1, R10.1, U1.7
unnamed: R2.1, SW1.B2
unnamed: R7.2, R8.1, SW7.B2
unnamed: R6.2, R7.1, SW6.B2
unnamed: R5.2, R6.1, SW5.B2
unnamed: R4.2, R5.1, SW4.B2
unnamed: R3.2, R4.1, SW3.B2
unnamed: R2.2, R3.1, SW2.B2
unnamed: R1.2, U1.3
unnamed: C1.1, U1.5
unnamed: LS1.-, Q1.C
unnamed: Q1.B, R1.1
TR: C2.1, SW1.A2, SW2.A2, SW3.A2, SW4.A2, SW5.A2, SW6.A2, SW7.A2, SW8.A2, U1.2, U1.6
VCC: BATT.+, LS1.+, R10.2, U1.4, U1.8

## Commit log

2019-05-16 WE DID SOME STUFF AND I DIDNT FINISH
2019-05-23 Yayyyyyy im Beethoven

Notices in the files:
parts and their libraries:
SparkFun-Switches: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
